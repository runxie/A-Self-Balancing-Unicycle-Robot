# IAR project NEW.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\CMSIS; ..\StdPeriph_Lib\inc; ..\User; ..\Peripherals
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: NEW.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Peripherals
    ../Peripherals/: ADXL345.c Bar.c key.c L3G4200D.c LCD_Dis.c Motor.c MotorCoder.c MotorCoder2.c
  group StdPeriph_Lib
    ../StdPeriph_Lib/src/: Delay.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c
    ../Peripherals/: I2C.c
  group StratUp
    ../StartUp/: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c
